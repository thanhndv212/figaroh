Commit message: up-to-date github Jan

File: scripts/models/others/robots/tiago_description/robots/tiago_no_hand_mod.urdf (robot description, URDF)
Before this commit: robot tiago, 39 links, 38 joints
Joints:
- joint ee_marker_joint: axis 1 0 0 -> 0 1 0; type revolute -> fixed
